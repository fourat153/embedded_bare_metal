# Keil uVision project x.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C1230C3PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x003000) IROM(0x00000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Embedded_C_Lesson_4_Lab_3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
